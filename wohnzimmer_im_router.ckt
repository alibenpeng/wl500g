* /usr/bin/gnetlist -v -g spice-sdb -o /home/ali/eagle/wl500g/wohnzimmer_im_router.ckt /home/ali/eagle/wl500g/wohnzimmer_im_router.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
.end
